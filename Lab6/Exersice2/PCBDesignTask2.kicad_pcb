# Repository matjg7/EE201

## KiCad design Lab6/Exersice2/PCBDesignTask2.kicad_pcb

Parts:
C1: 4.7µF; C_Radial_D5.0mm_H5.0mm_P2.00mm
D1: LED; LED_D5.0mm
J1: 9V; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R1: 20kΩ; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
R2: 2.2kΩ; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
SW1: .; SW_E-Switch_EG1224_SPDT_Angled

Connections:
unnamed: C1.1, R1.1, SW1.3 (C)
unnamed: C1.2, D1.1 (K), J1.2
unnamed: D1.2 (A), R1.2
unnamed: J1.1, R2.1
unnamed: R2.2, SW1.2 (B)

Board: 2 copper layers, 61.0 x 38.1 mm, 6 parts (0 on the bottom side), 5 nets.

## KiCad design Lab6/Exersice1/Task2Large.kicad_pcb

Parts:
C1: 10µF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C2: 0.01µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: conn; TerminalBlock_bornier-2_P5.08mm
R1, R3, R4: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: NE555D; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm

Connections:
+9V: D1.2 (A), J1.1, R1.1, U1.4 (R), U1.8 (VCC)
/pin_2: C1.1, R2.2, U1.2 (TR), U1.6 (THR)
/pin_3: R3.2, R4.1, U1.3 (Q)
/pin_7: R1.2, R2.1, U1.7 (DIS)
GND: C1.2, C2.2, D2.1 (K), J1.2, U1.1 (GND)
unnamed: C2.1, U1.5 (CV)
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), R4.2

Board: 2 copper layers, 55.9 x 38.1 mm, 10 parts (0 on the bottom side), 8 nets.

## Commit log

2023-01-13 pushing new branch
2023-01-20 Arduino
2023-01-27 lab4
2023-02-03 Soldering
2023-02-10 lab6
2023-02-17 lab7
2023-03-14 Lab8
